# Keil uVision project nucleo_stm32f429.uvprojx, settings and files
target ARMCC Debug (6140000::V6.14::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nucleo_stm32f429 +hex
  AfterMake: ..\..\utilities\windows\bin\hex2bin2crc.bat .\Debug_ARMCC\nucleo_stm32f429.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: DEBUG USE_STM32F4XX_NUCLEO_144 USE_HAL_DRIVER USE_FULL_LL_DRIVER __CMSIS_RTOS VECT_TAB_OFFSET=0x20000 EVR_RTX_DISABLE
  c include: .;.\src;..\shared;..\shared\ptpd\src;..\shared_nucleo;..\shared_stm32;..\shared_stm32\lwip_port;..\..\libraries\CMSIS\5.4.0\CMSIS\Core\Include;..\..\libraries\CMSIS\5.4.0\CMSIS\RTOS2\Include;..\..\libraries\CMSIS\5.4.0\CMSIS\RTOS2\RTX\Include;..\..\libraries\CMSIS\5.4.0\CMSIS\RTOS2\RTX\Source;..\..\libraries\CMSIS\5.4.0_ST\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_HAL_Driver\Inc;..\..\libraries\LWIP-2.1.2\src;..\..\libraries\LWIP-2.1.2\src\include;..\..\libraries\ntshell-v0.3.1\lib\core;..\..\libraries\ntshell-v0.3.1\lib\util
  asm include: .;..\shared
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x1e0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep=os_cb_sections
  group Startup GCC
    ../shared_stm32/startup/gcc/: startup_stm32f429xx.s
  group Startup ARMCC
    ../shared_stm32/startup/arm/: startup_stm32f429xx.s
  group Application
    ./src/: hal_system.h lwipopts.h stm32f4xx_hal_conf.h main.c hal_system.c
  group Application Shared
    ../shared/: crc.c cksum.c event.c outputf.c peek.c reboot.c shell.c syslog.c telnet.c uptime.c
  group Application Shared Nucleo
    ../shared_nucleo/: buttons.c leds.c
  group Application Shared STM32
    ../shared_stm32/: blink.c clocks.c console.c delay.c ethptp.c extint.c hardtime.c network.c ntime.c random.c systime.c system_stm32f4xx.c tick.c watchdog.c
  group Utilities
    ../shared/: newlib_stubs.c
  group Drivers
    ../../libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group NT Shell
    ../../libraries/ntshell-v0.3.1/lib/core/: ntlibc.c ntshell.c text_editor.c text_history.c vtrecv.c vtsend.c
    ../../libraries/ntshell-v0.3.1/lib/util/: ntopt.c ntstdio.c
  group PTPD
    ../shared/ptpd/src/: ptpd_arith.c ptpd_bmc.c ptpd_main.c ptpd_msg.c ptpd_net.c ptpd_protocol.c ptpd_servo.c ptpd_time.c ptpd_timer.c
  group LWIP API
    ../../libraries/LWIP-2.1.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP Core
    ../../libraries/LWIP-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group LWIP Core IPv4
    ../../libraries/LWIP-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LWIP Core IPv6
    ../../libraries/LWIP-2.1.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group LWIP Netif
    ../../libraries/LWIP-2.1.2/src/netif/: ethernet.c lowpan6.c
  group LWIP Port
    ../shared_stm32/lwip_port/: ethernetif.c sys_arch.c
  group LWIP Apps
    ../../libraries/LWIP-2.1.2/src/apps/mdns/: mdns.c
  group RTOS Config
    ./src/: RTX_Config.c RTX_Config.h
  group RTOS Kernel
    ../../libraries/CMSIS/5.4.0/CMSIS/RTOS2/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../libraries/CMSIS/5.4.0/CMSIS/RTOS2/Source/: os_systick.c
  group RTOS IRQ GCC
    ../../libraries/CMSIS/5.4.0/CMSIS/RTOS2/RTX/Source/GCC/: irq_cm4f.S
  group RTOS IRQ ARMCC
    ../../libraries/CMSIS/5.4.0/CMSIS/RTOS2/RTX/Source/ARM/: irq_cm4f.s
target ARMCC Release (6140000::V6.14::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nucleo_stm32f429 +hex
  AfterMake: ..\..\utilities\windows\bin\hex2bin2crc.bat .\Release_ARMCC\nucleo_stm32f429.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: NDEBUG USE_STM32F4XX_NUCLEO_144 USE_HAL_DRIVER USE_FULL_LL_DRIVER __CMSIS_RTOS VECT_TAB_OFFSET=0x20000 EVR_RTX_DISABLE
  c include: as above
  asm include: .;..\shared
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x1e0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep=os_cb_sections
target GCC Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: nucleo_stm32f429
  AfterMake: ..\..\utilities\windows\bin\hex2bin2crc.bat .\Debug_GCC\nucleo_stm32f429.hex
target GCC Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: nucleo_stm32f429 +hex
  AfterMake: ..\..\utilities\windows\bin\hex2bin2crc.bat .\Release_GCC\nucleo_stm32f429.hex
